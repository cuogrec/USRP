options:
  parameters:
    author: Muhammed
    generate_options: qt_gui
    id: bpsk_qpsk_16QAM
    output_language: python
  states: {}

blocks:
- name: QAM16
  id: variable
  parameters:
    value: '[-1-1j, +1-1j, 1+1j,-1+1j,1+3j, 3+1j, 3+3j, -1+3j, -3+1j, -3+3j, 3-1j, 1-3j, 3-3j, -3-1j, -1-3j, -3-3j]'
  states: {}
- name: bpsk
  id: variable
  parameters:
    value: '[-1+0j,1+0j]'
  states: {}
- name: cfo
  id: variable_qtgui_range
  parameters:
    label: Carrier Frequency Offset (Hz)
    start: '0'
    step: '10'
    stop: 100e3
    value: '0.0'
  states: {}
- name: constellation
  id: variable_qtgui_chooser
  parameters:
    label0: bpsk
    label1: qpsk
    label2: QAM16
    num_opts: '3'
    option0: bpsk
    option1: qpsk
    option2: QAM16
    orient: Qt.QHBoxLayout
    type: raw
    value: qpsk
    widget: radio_buttons
  states: {}
- name: mod_order
  id: variable
  parameters:
    comment: |-
      The number of bits that each 
      constellation point carries
    value: '2'
  states: {}
- name: noise
  id: variable_qtgui_range
  parameters:
    label: Noise Amplitude
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.0'
  states: {}
- name: qpsk
  id: variable
  parameters:
    value: '[1+1j, 1-1j, -1+1j,-1-1j]'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e6
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/thuy-anh/Desktop/tesstttt/data_thu.dat
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/thuy-anh/Desktop/hello.dat
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: mod_order
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: constellation
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '4'
    w: '0.0628'
  states: {state: disabled}
- name: digital_psk_demod_0
  id: digital_psk_demod
  parameters:
    constellation_points: '8'
    differential: 'True'
    excess_bw: '0.35'
    freq_bw: 6.28/100.0
    mod_code: '"gray"'
    phase_bw: 6.28/100.0
    samples_per_symbol: '2'
    timing_bw: 6.28/100.0
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', digital_psk_demod_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_file_sink_0, '0']
- [digital_psk_demod_0, '0', blocks_file_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
